# Keil uVision project IOT.uvprojx, settings and files
target IOT (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: IOT +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../onenet/device/inc;../onenet/onenet/inc;../onenet/CJSON;../onenet/MQTT;..\modules\middleware\inc;..\modules\app\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: adcx.c LDR.c oled.c LED.c beep.c dht11.c myi2c.c myusart.c delay.c Key.c TS.c usart3.c bump.c Display.c fan.c jdq.c main.c gpio.c adc.c i2c.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group modules/app
    ../modules/app/src/: app_vgus.c app_network_startup.c app_pump_port.c app_climate_port.c app_alarm_port.c app_key_port.c app_sensor_port.c app_led_port.c app_commands.c app_sensors.c app_config.c app_config_port.c
  group modules/middleware
    ../modules/middleware/src/: mw_irrigation.c mw_climate.c mw_alarm.c mw_command.c mw_config.c mw_filter.c mw_pid.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group onenet
    ../onenet/onenet/src/: onenet_command.c base64.c hmac_sha1.c onenet.c
    ../onenet/CJSON/: cJSON.c
    ../onenet/device/src/: esp8266.c
    ../onenet/MQTT/: MqttKit.c
software components: CMSIS:CORE 4.3.0
